# Keil uVision project Project.uvprojx, settings and files
target GD32C11X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C113CB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C11X
  c misc: --diag_suppress=1295
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32C11x\Include;..\Libraries\GD32C11x_standard_peripheral\Include;..\Bsp;..\App;..\EtherCAT
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../App/: gd32c11x_it.c main.c ECATSlave_V100.c
  group Ecat/Src
    ../EtherCAT/: coeappl.c ecatappl.c ecatcoe.c ecatslv.c mailbox.c objdef.c sdoserv.c el9800hw.c
  group Bsp
    ../Bsp/: bsp_systick.c bsp_led.c bsp_spi.c bsp_timer.c ax58100.c
  group Libraries
    ../Libraries/GD32C11x_standard_peripheral/Source/: gd32c11x_exti.c gd32c11x_misc.c gd32c11x_rcu.c gd32c11x_gpio.c gd32c11x_spi.c gd32c11x_timer.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
    ../Libraries/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
